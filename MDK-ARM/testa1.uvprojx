# Keil uVision project testa1.uvprojx, settings and files
target testa1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: testa1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx,__TARGET_FPU_VFP,ARM_MATH_CM4
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Core/Inc/Algorithm;../Core/Inc/Application;../Core/Inc/Library;../Core/Inc/Modules;../Core/Inc/Periphal;../Core/Inc/System;../Core/Inc/Utility;../Drivers/CMSIS/DSP/Include;../MDK-ARM;../Core/Inc/Communicate
  asm include: ../Core/Inc;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../Core/Src/Application/: app_init.c app_communicate.c app_platform.c app_remote.c app_gimbal.c app_chassis.c app_serve.c app_rise.c
  group Module
    ../Core/Src/Modules/: module_platform.c module_chassis.c module_serve.c module_rise.c
  group Periphal
    ../Core/Src/Periphal/: periph_motor.c periph_remote.c periph_dt35.c
  group Utility
    ../Core/Src/Utility/: util_can.c util_gpio.c util_uart.c util_vofa.c util_bluetooth_tune.c
  group Communicate
    ../Core/Src/Communicate/: comm_common.c comm_receive.c comm_transmit.c
  group System
    ../Core/Src/System/: sys_const.c sys_dwt.c
  group Library
    ../Core/Src/Library/: lib_buff.c lib_delay.c lib_font.c lib_gif.c lib_list.c lib_music.c lib_queue.c lib_str.c lib_tree.c
    ./: arm_cortexM4lf_math.lib
  group Algorithm
    ../Core/Src/Algorithm/: alg_crc.c alg_filter.c alg_kalman.c alg_math.c alg_pid.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
software components: CMSIS:CORE 5.4.0
